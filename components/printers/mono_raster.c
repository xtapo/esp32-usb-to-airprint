#include "mono_raster.h"

#include <stdio.h>
#include <string.h>

// 8x8 Bayer threshold matrix scaled to 0..255
static const uint8_t BAYER8[8][8] = {
    {  0, 128,  32, 160,   8, 136,  40, 168},
    {192,  64, 224,  96, 200,  72, 232, 104},
    { 48, 176,  16, 144,  56, 184,  24, 152},
    {240, 112, 208,  80, 248, 120, 216,  88},
    { 12, 140,  44, 172,   4, 132,  36, 164},
    {204,  76, 236, 108, 196,  68, 228, 100},
    { 60, 188,  28, 156,  52, 180,  20, 148},
    {252, 124, 220,  92, 244, 116, 212,  84},
};

// Minimal 5x7 ASCII font (0x20..0x7E) for test page header text
static const uint8_t FONT5X7[95][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5f, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7f, 0x14, 0x7f, 0x14}, {0x24, 0x2a, 0x7f, 0x2a, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x56, 0x20, 0x50}, {0x00, 0x00, 0x07, 0x00, 0x00}, {0x00, 0x1c, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1c, 0x00}, {0x2a, 0x1c, 0x7f, 0x1c, 0x2a}, {0x08, 0x08, 0x3e, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02}, {0x3e, 0x51, 0x49, 0x45, 0x3e}, {0x00, 0x42, 0x7f, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4b, 0x31}, {0x18, 0x14, 0x12, 0x7f, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3c, 0x4a, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1e}, {0x00, 0x36, 0x36, 0x00, 0x00},
    {0x00, 0x56, 0x36, 0x00, 0x00}, {0x08, 0x14, 0x22, 0x41, 0x00}, {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06}, {0x32, 0x49, 0x79, 0x41, 0x3e},
    {0x7e, 0x11, 0x11, 0x11, 0x7e}, {0x7f, 0x49, 0x49, 0x49, 0x36}, {0x3e, 0x41, 0x41, 0x41, 0x22},
    {0x7f, 0x41, 0x41, 0x22, 0x1c}, {0x7f, 0x49, 0x49, 0x49, 0x41}, {0x7f, 0x09, 0x09, 0x09, 0x01},
    {0x3e, 0x41, 0x49, 0x49, 0x7a}, {0x7f, 0x08, 0x08, 0x08, 0x7f}, {0x00, 0x41, 0x7f, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3f, 0x01}, {0x7f, 0x08, 0x14, 0x22, 0x41}, {0x7f, 0x40, 0x40, 0x40, 0x40},
    {0x7f, 0x02, 0x0c, 0x02, 0x7f}, {0x7f, 0x04, 0x08, 0x10, 0x7f}, {0x3e, 0x41, 0x41, 0x41, 0x3e},
    {0x7f, 0x09, 0x09, 0x09, 0x06}, {0x3e, 0x41, 0x51, 0x21, 0x5e}, {0x7f, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7f, 0x01, 0x01}, {0x3f, 0x40, 0x40, 0x40, 0x3f},
    {0x1f, 0x20, 0x40, 0x20, 0x1f}, {0x3f, 0x40, 0x38, 0x40, 0x3f}, {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}, {0x00, 0x7f, 0x41, 0x41, 0x00},
    {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x7f, 0x00}, {0x04, 0x02, 0x01, 0x02, 0x04},
    {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x01, 0x02, 0x04, 0x00}, {0x20, 0x54, 0x54, 0x54, 0x78},
    {0x7f, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20}, {0x38, 0x44, 0x44, 0x48, 0x7f},
    {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7e, 0x09, 0x01, 0x02}, {0x18, 0xa4, 0xa4, 0xa4, 0x7c},
    {0x7f, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7d, 0x40, 0x00}, {0x20, 0x40, 0x44, 0x3d, 0x00},
    {0x7f, 0x10, 0x28, 0x44, 0x00}, {0x00, 0x41, 0x7f, 0x40, 0x00}, {0x7c, 0x04, 0x18, 0x04, 0x78},
    {0x7c, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38}, {0xfc, 0x24, 0x24, 0x24, 0x18},
    {0x18, 0x24, 0x24, 0x24, 0xfc}, {0x7c, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x20},
    {0x04, 0x3f, 0x44, 0x40, 0x20}, {0x3c, 0x40, 0x40, 0x20, 0x7c}, {0x1c, 0x20, 0x40, 0x20, 0x1c},
    {0x3c, 0x40, 0x30, 0x40, 0x3c}, {0x44, 0x28, 0x10, 0x28, 0x44}, {0x1c, 0xa0, 0xa0, 0xa0, 0x7c},
    {0x44, 0x64, 0x54, 0x4c, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x7f, 0x00, 0x00},
    {0x00, 0x41, 0x36, 0x08, 0x00}, {0x08, 0x04, 0x08, 0x10, 0x08},
};

void mono_rgb_to_density(const uint8_t *px, int src_w, int bytes_pp, uint8_t *density, int dst_w)
{
    if (!px || src_w <= 0) {
        memset(density, 0, (size_t)dst_w);
        return;
    }
    int n = src_w < dst_w ? src_w : dst_w;
    if (bytes_pp == 1) {
        for (int x = 0; x < n; x++)
            density[x] = (uint8_t)(255 - px[x]);
    } else {
        for (int x = 0; x < n; x++) {
            const uint8_t *p = px + x * bytes_pp;
            uint32_t lum = (77u * p[0] + 150u * p[1] + 29u * p[2]) >> 8;
            density[x] = (uint8_t)(255u - lum);
        }
    }
    if (n < dst_w)
        memset(density + n, 0, (size_t)(dst_w - n));
}

void mono_dither_1bit(const uint8_t *density, int width, int y, uint8_t *out, int out_bytes)
{
    const uint8_t *row = BAYER8[y & 7];
    memset(out, 0, (size_t)out_bytes);
    for (int x = 0; x < width; x++) {
        if (density[x] > row[x & 7])
            out[x >> 3] |= (uint8_t)(0x80u >> (x & 7));
    }
}

static void set_px(uint8_t *out, int width, int x)
{
    if (x >= 0 && x < width)
        out[x >> 3] |= (uint8_t)(0x80u >> (x & 7));
}

static void draw_hline(uint8_t *out, int width, int x0, int x1)
{
    if (x0 < 0)
        x0 = 0;
    if (x1 >= width)
        x1 = width - 1;
    for (int x = x0; x <= x1; x++)
        set_px(out, width, x);
}

static void draw_text_row(uint8_t *out, int width, int x0, int scale, int gy, const char *s)
{
    if (!s || gy < 0 || gy >= 8)
        return;
    int x = x0;
    for (; *s; s++) {
        unsigned char c = (unsigned char)*s;
        int idx = (c >= 0x20 && c <= 0x7e) ? (c - 0x20) : ('?' - 0x20);
        for (int col = 0; col < 5; col++) {
            if (FONT5X7[idx][col] & (1u << gy))
                for (int sx = 0; sx < scale; sx++)
                    set_px(out, width, x + col * scale + sx);
        }
        x += 6 * scale;
    }
}

void mono_testpage_line(int y, int width, int height, int dpi, const char *title, const char *label, uint8_t *out,
                        int out_bytes)
{
    memset(out, 0, (size_t)out_bytes);
    int pad = dpi / 4;          // 0.25 in margin
    int thick = dpi / 150;      // 2 px at 300 dpi, 4 px at 600 dpi
    if (thick < 1)
        thick = 1;

    // Outer frame
    if ((y >= pad && y < pad + thick) || (y >= height - pad - thick && y < height - pad)) {
        draw_hline(out, width, pad, width - pad - 1);
        return;
    }
    if (y > pad && y < height - pad) {
        for (int t = 0; t < thick; t++) {
            set_px(out, width, pad + t);
            set_px(out, width, width - pad - 1 - t);
        }
    }

    // Inch ruler ticks along left/right inner edges
    if (y >= pad && y < height - pad && ((y - pad) % dpi) < thick * 2) {
        draw_hline(out, width, pad, pad + dpi / 8);
        draw_hline(out, width, width - pad - 1 - dpi / 8, width - pad - 1);
    }

    // Header text block
    int scale = dpi >= 600 ? 8 : 4;
    int ty1 = pad + dpi / 3;
    int ty2 = ty1 + 10 * scale;
    int ty3 = ty2 + 10 * scale;
    if (y >= ty1 && y < ty1 + 8 * scale)
        draw_text_row(out, width, pad + dpi / 4, scale, (y - ty1) / scale, title ? title : "AirPrint Test Page");
    else if (y >= ty2 && y < ty2 + 8 * scale) {
        char info[64];
        snprintf(info, sizeof(info), "%d dpi  %dx%d", dpi, width, height);
        draw_text_row(out, width, pad + dpi / 4, scale * 3 / 4, (y - ty2) / (scale * 3 / 4), info);
    } else if (label && y >= ty3 && y < ty3 + 8 * scale) {
        int s2 = scale / 2;
        if (s2 < 1)
            s2 = 1;
        draw_text_row(out, width, pad + dpi / 4, s2, (y - ty3) / s2, label);
    }

    // Halftone gradient ramp band
    int ramp_top = ty3 + 12 * scale;
    int ramp_bot = ramp_top + dpi / 2;
    int rx0 = pad + dpi / 4;
    int rx1 = width - pad - dpi / 4;
    if (y >= ramp_top && y < ramp_bot && rx1 > rx0) {
        if (y < ramp_top + thick || y >= ramp_bot - thick) {
            draw_hline(out, width, rx0, rx1);
        } else {
            const uint8_t *bayer = BAYER8[y & 7];
            int rw = rx1 - rx0;
            for (int x = rx0; x <= rx1; x++) {
                uint8_t d = (uint8_t)(((x - rx0) * 255) / rw);
                if (d > bayer[x & 7])
                    set_px(out, width, x);
            }
        }
    }

    // Diagonal cross in lower half to verify geometry and no line drops
    int box_top = ramp_bot + dpi / 3;
    int box_bot = height - pad - dpi / 3;
    if (y >= box_top && y <= box_bot && box_bot > box_top) {
        int bh = box_bot - box_top;
        int bw = rx1 - rx0;
        int rel_y = y - box_top;
        int x_a = rx0 + (int)((int64_t)rel_y * bw / bh);
        int x_b = rx1 - (int)((int64_t)rel_y * bw / bh);
        for (int t = -thick; t <= thick; t++) {
            set_px(out, width, x_a + t);
            set_px(out, width, x_b + t);
        }
    }
}
